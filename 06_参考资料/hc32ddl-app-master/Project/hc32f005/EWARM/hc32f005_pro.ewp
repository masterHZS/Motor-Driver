# IAR project hc32f005_pro.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: HC32F005C6PA HDSC HC32F005C6PA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG
  ICCARM.CCIncludePath2: ..; ..\..\..\Drivers\hc32f005; ..\..\..\Drivers\hc32f005\inc; ..\..\..\User\API; ..\..\..\User\Application\inc; ..\..\..\User\Common\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: hc32f005_pro.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: hc32f003.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Drivers/EWARM
    ./: startup_hc32f005.s
  group Drivers/StdPeriph_Lib
    ../../../Drivers/hc32f005/src/: adc.c adt.c bgr.c bt.c crc.c ddl.c flash.c gpio.c i2c.c lpm.c lvd.c pca.c ram.c reset.c spi.c sysctrl.c trim.c uart.c vc.c wdt.c
  group Project
    ../: interrupts_hc32f005.c main.c system_hc32f005.c
  group User/Api
    ../../../User/Api/: amx_api.c amx_fifo.c amxlink.c
  group User/APP
    ../../../User/Application/src/: hc_gpio.c hc_timer.c hc_uart.c
  group User/Common
    ../../../User/Common/src/: delay.c

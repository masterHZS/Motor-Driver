# Keil uVision project hc32f00x.uvprojx, settings and files
target HC32F003 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F003C4PA HDSC
  pack: HDSC.HC32F003.1.0.1
  cpu: IRAM(0x20000000,0x800) IROM(0x00000000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: hc32f00x +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: --diag_suppress=1
  c include: ..\MDK;..\..\hc32f005;..\..\..\Drivers\hc32f005\inc;..\..\..\User;..\..\..\User\Common;..\..\..\User\Common\inc;..\..\..\User\Application;..\..\..\User\Application\inc;..\..\..\User\API
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  link misc: --keep=*Handler
  group Drivers
    ../../../Drivers/hc32f005/src/: adc.c adt.c bgr.c bt.c crc.c ddl.c flash.c gpio.c i2c.c lpm.c lvd.c pca.c ram.c reset.c spi.c sysctrl.c trim.c uart.c vc.c wdt.c
  group Project
    ../: interrupts_hc32f005.c main.c system_hc32f005.c
    ./: startup_hc32f005.s
  group Api
    ../../../User/Api/: amx_api.c amx_fifo.c amxlink.c
  group Application
    ../../../User/Application/src/: hc_timer.c hc_gpio.c hc_uart.c
  group Common
    ../../../User/Common/src/: delay.c
target HC32F005 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F005C6PA HDSC
  pack: HDSC.HC32F005.1.0.1
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: hc32f00x +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: --diag_suppress=1
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
software components: CMSIS:CORE 5.4.0
